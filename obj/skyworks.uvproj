# Keil uVision project skyworks.uvproj, settings and files
target DEBUG (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(24000000) ELITTLE
  output: skyworks +hex
  c flags: Optim=1
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM3
  c include: ..\lib\CMSIS\inc;..\lib\STM32F10x_StdPeriph_Driver\inc;..\user;..\mpu6000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: main.c stm32f10x_it.c
  group periph_lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group system
    ../lib/CMSIS/src/: system_stm32f10x.c
  group cmsis_dsp
    ../lib/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
  group mpu6000
    ../mpu6000/: MPU6000.c
target RELEASE (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: skyworks +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: ..\lib\CMSIS\inc;..\lib\STM32F10x_StdPeriph_Driver\inc;..\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
